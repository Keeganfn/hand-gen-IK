Commit message: working better

File: resources/2v2_Demo/object/2v2_Demo_cuboid_small.urdf (robot description, URDF)
Before this commit: robot 2v2_Demo_cuboid_small, 1 links, 0 joints
Links:
- link 2v2_Demo_cuboid_small: mass None -> 5
